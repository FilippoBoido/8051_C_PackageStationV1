# Keil uVision project 8051_C_PackageStation.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S8253 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: 8051_C_PackageStation +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: system.h io.h main.c process1.h process2.h processVars.h processFunctions.h sot.h utilities.h process1.c process2.c processFunctions.c utilities.c system.c processVars.c
